# Keil uVision project rainTIC.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rainTIC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: .\Libraries\FWLIB\Include;.\Libraries\CMSIS;.\USER;.\Project\RTE;.\HARDWARE;.\HARDWARE\MLX90640\headers;.\FATFS;.\USB;.\USB\GD32F10x_usbd_driver\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Libraries/CMSIS/startup/: startup_gd32f10x_hd.s
  group FWLB
    ./Libraries/FWLIB/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ./Libraries/CMSIS/: system_gd32f10x.c
  group USER
    ./USER/: main.c gd32f10x_it.c systick.c config.h
  group HARDWARE
    ./HARDWARE/: XT25F128.c ADCKey.c bmp.c GPIO.c TIM.c gd32f103c_lcd_eval.c
    ./HARDWARE/MLX90640/functions/: MLX90640.c MLX90640_API.c MLX90640_SWI2C_Driver.c
  group USB
    ./USB/: bbb_scsi_driver.c flash_access.c msc_core.c
    ./USB/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group FATFS
    ./FATFS/: diskio.c ff.c
